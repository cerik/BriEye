# Keil uVision project BriEye.uvproj, settings and files
target 1 (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: BriEye +hex
  c flags: Optim=1
  c define: STM32F10X_XL=1
  c include: .\Src;.\usb;.\Bsp;.\Bsp\inc;.\Bsp\src;.\Bsp\cmsis;.\uCOS-II;.\uCOS-II\Src;.\uCOS-II\Lib;.\uCOS-II\Cpu;.\uCOS-II\Ports;.\uCOS-II\Lib\Ports;.\Scpi;.\Scpi\Core
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Bsp
    ./Bsp/: system_stm32f10x.c startup_stm32f10x.s
    ./Bsp/src/: stm32f10x_iwdg.c stm32f10x_gpio.c stm32f10x_flash.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c misc.c stm32f10x_exti.c stm32f10x_spi.c
    ./Bsp/cmsis/: core_cm3.c
  group Src
    ./Src/: main.c flash.c platform.c crc.c cmd.c UartDrv.c sysdb.c ad7731.c lcd.c
  group usb
    ./usb/: hw_config.c usb_core.c usb_desc.c usb_init.c usb_int.c usb_istr.c usb_mem.c usb_prop.c usb_pwr.c usb_regs.c usb_tmc.c
  group uC-Core
    ./uCOS-II/Src/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uC-CPU
    ./uCOS-II/Cpu/: cpu_a.asm cpu_c.c
  group uC-Lib
    ./uCOS-II/Lib/: lib_str.c lib_mem.c
  group uC-Port
    ./uCOS-II/Ports/: os_cpu_a.asm os_cpu_c.c os_dbg.c
  group Scpi
    ./Scpi/Core/: debug.c error.c fifo.c ieee488.c minimal.c parser.c snprintf.c units.c utils.c
    ./Scpi/: scip-def.c
